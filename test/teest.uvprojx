# Keil uVision project teest.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: teest
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS Driver:CAN:Custom 1.0.0, CMSIS Driver:GPIO:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, CMSIS Driver:GPIO 1.2.0, CMSIS Driver:USART 3.0.0, Compiler:Event Recorder 1.4.0
